## sdkconfig.defaults
```kconfig
CONFIG_ESP_MAIN_TASK_STACK_SIZE=16384
CONFIG_ESP_TASK_WDT_TIMEOUT_S=30
CONFIG_ESP_WIFI_ENABLE_WPA3_SAE=y
CONFIG_WPA_MBEDTLS_CRYPTO=y
```
